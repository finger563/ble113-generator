# IAR project project.ewp, settings and files
configuration debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2541F256.i51
  General.RTConfigPath: $TOOLKIT_DIR$\LIB\DLIB\dl8051Normal.h
  ICC8051.CCDefines: BG_DEBUG
  ICC8051.CCDiagSuppress: Pa050,Ta045
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: $EW_DIR$\Bluegiga\ble-1.5\include
  ICC8051.CCOptLevel: 3
  ICC8051.CCOptStrategy: 0
  ICC8051.IccLang: 0
  prebuild: "$EW_DIR$\Bluegiga\ble-1.5\bin\bgbuild.exe" "config\project.bgproj"
  XLINK.XclFile: blestack256_debug.xcl
configuration release (8051)
  as the first configuration, except:
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2540F128.i51
  XLINK.XclFile: blestack256.xcl
configuration bgbuild (8051)
  as the first configuration, except:
  postbuild: "$EW_DIR$\Bluegiga\ble-1.5\bin\fwmem.exe" "bgbuild\list\$TARGET_BNAME$.map" "$TARGET_BPATH$.mem"
  XLINK.XclFile: blestack256_bgbuild.xcl
  group (top)
    $EW_DIR$/Bluegiga/ble-1.5/lib/: blestack2541.r51
    ./: blestack256.xcl blestack256_debug.xcl blestack256_bgbuild.xcl
  group APP
    src/: main.c
  group Config
    config/: config.xml gatt.xml hardware.xml license.xml project.bgproj
